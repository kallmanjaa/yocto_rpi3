SUMMARY = "Navigation"
DESCRIPTION = "Qt navigation app [autostart]"
LICENSE = "MIT"

